inherit core-image
IMAGE_INSTALL = "linux-libc-headers-dbg linux-libc-headers-dev glibc update-rc.d base-files update-alternatives-opkg zlib libcrypto openssl-conf shadow-base shadow base-passwd shadow-securetty util-linux-sulogin perl perl-lib run-postinsts busybox-udhcpc busybox-syslog busybox dropbear kernel-base "
DESCRIPTION = ""
