require /opt/poky/meta/recipes-core/images/core-image-minimal.bb
IMAGE_INSTALL = "glibc update-alternatives-opkg shadow-base shadow base-passwd shadow-securetty util-linux-sulogin perl perl-lib "
DESCRIPTION = ""
