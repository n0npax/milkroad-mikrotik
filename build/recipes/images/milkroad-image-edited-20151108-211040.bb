require /opt/poky/meta/recipes-core/images/core-image-minimal.bb
IMAGE_INSTALL = "glibc update-rc.d base-files update-alternatives-opkg zlib libcrypto openssl-conf shadow-base shadow base-passwd shadow-securetty util-linux-sulogin perl perl-lib run-postinsts busybox-udhcpc busybox-syslog busybox openssh-keygen openssh-scp openssh-ssh openssh-sshd openssh kernel-base kernel-module-configfs "
DESCRIPTION = ""
